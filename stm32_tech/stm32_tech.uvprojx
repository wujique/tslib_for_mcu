# Keil uVision project stm32_tech.uvprojx, settings and files
target stm32_tech (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_tech +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\mcu;.\mcu\StLib\inc;.\dev;.\dev\tslib;.\dev\tslib\tests
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group mcu
    ./mcu/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Stlib
    ./mcu/StLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./mcu/: main.c
  group dev
    ./dev/: font_8x8.c dev_ILI9341.c mcu_fsmc.c bus_vspi.c dev_touchscreen.c dev_xpt2046.c
    ./dev/tslib/: tslib.c
    ./dev/tslib/tests/: ts_calibrate.c testutils.c
